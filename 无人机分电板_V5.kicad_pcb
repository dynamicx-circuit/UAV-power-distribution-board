# Repository dynamicx-circuit/UAV-power-distribution-board

File README.md:

#### 这是一个通过24V电池二串三并提高到48V的分电板
该版本采用LM5050-2作为理想二极管控制器以防止电池间互充。
#### 现存问题
1.现在无人机使用的为第5版，板上的48V降24V并未投入使用。<br>
2.使用该板时应注意电池的电压尽量保持一致，持续工作时间应小于10min，以避免电池过热。<br>
3.实机测试时MOS管需安装散热片并配合散热风扇使用，以免MOS热击穿。<br>
4.若要进行实机测试，***一定要在48V输出和GDN之间接入气体放电管***，并且***切记不可在48V输出和GND之间接入压敏电阻***。（接入压敏电阻后在限流情况下，输出电压较输入电压低2V~3V，未限流情况下，压敏电阻会在接GND的一侧炸裂，目前原因不明。）<br>
5.尽量使用高温锡焊接。<br>
6.该版本的地回路并未进行开窗，输出地较电池负极端距离较远。<br>

## KiCad design 无人机分电板_V5.kicad_pcb

Parts:
BT1, BT2, BT3, BT4, BT5, BT6: Battery; AMASS_XT60-M_1x02_P7.20mm_Vertical
C1, C2, C3: 0.1uF/100V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C5, C6: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C17: 470uF; CP_Elec_6.3x7.7
C8, C13, C18, C25: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 470pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10: 33nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11: 6.8pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12: 180pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14, C15: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16, C19, C20: 100uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21: 1nf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C22, C24: 100nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C23: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3: D; D_SOD-123
D4, D6, D7, D9: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: FR107; D_SOD-123
D10, D11: SMD4532-075; D_1812_4532Metric_Pad1.30x3.40mm_HandSolder
J1, J2, J3, J4, J5, J6: Conn_01x02; AMASS_XT60-F_1x02_P7.20mm_Vertical
J7: Conn_01x02; AMASS_XT30U-F_1x02_P5.0mm_Vertical
L1: 8.2uH; L_Wuerth_HCI-1365
Q1, Q2, Q3, Q4, Q5, Q6: IPT015N10N5; Infineon_PG-HSOF-8-1
Q7, Q8: CSD18540; VSONP-8-1EP_5x6_P1.27mm
R1: 10K/NC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 52k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 5.23k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 221k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8, R9: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R12: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R17, R18: 24k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 11.8k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 169k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 10R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20: 6mO; R_2010_5025Metric_Pad1.40x2.65mm_HandSolder
R21: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U2, U3: LM5050-2; TSOT-23-6
U4: LM5116; HTSSOP-20-1EP_4.4x6.5mm_P0.65mm_EP2.85x4mm

Connections:
+24V: C16.1, C17.1, C18.1, C20.1, C21.1, C24.1, J5.1, J6.1, L1.2, R6.2, R21.1, U4.10 (VOUT)
+48V: C1.1, C2.1, C3.1, C7.1, C8.1, C19.1, C22.1, C23.1, D10.2 (A2), D11.2 (A2), J1.1, J2.1, J3.1, J4.1, J7.1, Q1.3 (D), Q2.3 (D), Q3.3 (D), Q4.3 (D), Q5.3 (D), Q6.3 (D), Q7.3 (D), R2.2, R5.2, U1.6 (OUT), U2.6 (OUT), U3.6 (OUT), U4.1 (VIN); also elsewhere on the board
GNDPWR: BT1.2 (-), BT2.2 (-), BT3.2 (-), C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C22.2, C23.2, C24.2, D4.1 (K), D6.1 (K), D7.1 (K), D9.1 (K), D10.1 (A1), D11.1 (A1), J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, R1.1, R3.1, R4.1, R7.2, R8.2, R9.2, R14.1, R16.1, R20.1, U1.2 (GND), U1.3 (OFF), U2.2 (GND), U2.3 (OFF), U3.2 (GND), U3.3 (OFF), U4., U4.6 (AGND), U4.13 (CSG), U4.14 (PGND), U4.21 (EP); also elsewhere on the board
unnamed: BT1.1 (+), BT4.2 (-)
unnamed: BT2.1 (+), BT5.2 (-)
unnamed: BT3.1 (+), BT6.2 (-)
unnamed: BT4.1 (+), Q1.2 (S), Q2.2 (S), R13.1, U1.4 (IN)
unnamed: BT5.1 (+), Q3.2 (S), Q4.2 (S), R17.1, U2.4 (IN)
unnamed: BT6.1 (+), Q5.2 (S), Q6.2 (S), R18.1, U3.4 (IN)
unnamed: C1.2, R7.1, U1.1 (~FGD)
unnamed: C2.2, R8.1, U2.1 (~FGD)
unnamed: C3.2, R9.1, U3.1 (~FGD)
unnamed: C4.1, D1.1 (K), R10.2
unnamed: C5.1, D2.1 (K), R11.2
unnamed: C6.1, D3.1 (K), R12.2
unnamed: C9.1, U4.5 (RAMP)
unnamed: C10.1, U4.7 (SS)
unnamed: C11.1, C12.1, C21.2, R6.1, R14.2, U4.8 (FB)
unnamed: C11.2, R15.2, U4.9 (COMP)
unnamed: C12.2, R15.1
unnamed: C13.1, C25.1, L1.1, Q7.2 (S), Q8.3 (D), U4.20 (SW)
unnamed: C13.2, D8.1 (K), U4.18 (HB)
unnamed: C14.1, D8.2 (A), U4.16 (VCC)
unnamed: C15.1, U4.17 (VCCX)
unnamed: C25.2, R16.2
unnamed: D1.2 (A), Q1.1 (G), Q2.1 (G), R10.1, U1.5 (GATE)
unnamed: D2.2 (A), Q3.1 (G), Q4.1 (G), R11.1, U2.5 (GATE)
unnamed: D3.2 (A), Q5.1 (G), Q6.1 (G), R12.1, U3.5 (GATE)
unnamed: D4.2 (A), R13.2
unnamed: D6.2 (A), R17.2
unnamed: D7.2 (A), R18.2
unnamed: D9.2 (A), R21.2
unnamed: Q7.1 (G), U4.19 (HO)
unnamed: Q8.1 (G), U4.15 (LO)
unnamed: Q8.2 (S), R20.2, U4.12 (CS)
unnamed: R1.2, U4.11 (DEMB)
unnamed: R2.1, R3.2, U4.2 (UVLO)
unnamed: R4.2, U4.3 (RT/SYNC)
unnamed: R5.1, U4.4 (EN)

Notes on the sheet:
》 本版改动： ·增加了DEMB处的电阻，以选择是否使用二极管仿真。 ·将地改为GNDPWR ·删掉了HO,LO栅极串联电阻。 ·增加输入输出电容。 》 PCB待改动： 功率回路、敏感信号区分；补偿网络贴近；
MOS管改为IPT015N10N5 增加了浪涌保护器件

Board: 2 copper layers, 87.8 x 57.7 mm, 83 parts (11 on the bottom side), 39 nets.

Other parts of the board:
R19, R22: Varistor_82V; R_1812_4532Metric_Pad1.30x3.40mm_HandSolder

Their connections:
+48V: R19.1, R22.1; also elsewhere on the board
GNDPWR: R19.2, R22.2; also elsewhere on the board
